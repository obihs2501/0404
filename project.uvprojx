# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\User;.\Library;.\System;.\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c core_cm3.h system_stm32f10x.c stm32f10x.h system_stm32f10x.h startup_stm32f10x_hd.s
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h
  group Hardware
    ./Hardware/: motor.c motor.h encoder.c encoder.h control.c control.h exti.c exti.h MPU6050.c MPU6050.h My_PID.c My_PID.h My_Math.c My_Math.h My_Usart.c My_Usart.h Serial.c Serial.h Key.c Key.h Servo.c Servo.h dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h IOI2C.c IOI2C.h sys.c sys.h usart.c usart.h OLED.c OLED.h OLED_Data.c OLED_Data.h pstwo.c pstwo.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
